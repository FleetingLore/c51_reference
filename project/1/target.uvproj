# Keil uVision project target.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: target +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c
    ./lib/key/: k1_on.c k2_on.c k3_on.c k4_on.c
    ./lib/display/: mode_1.c mode_2.c mode_3.c
    ./lib/delay/: async_delay_ms_for_k2.c delay_ms.c
  group doc
    ./: local.md
